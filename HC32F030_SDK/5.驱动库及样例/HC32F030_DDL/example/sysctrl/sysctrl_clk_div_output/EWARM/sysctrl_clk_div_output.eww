<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sysctrl_clk_div_output.ewp</path>
  </project>
  <batchBuild/>
</workspace>


