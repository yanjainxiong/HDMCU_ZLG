<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dma_hw_trigger_burst.ewp</path>
  </project>
  <batchBuild/>
</workspace>


