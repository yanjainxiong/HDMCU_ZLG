# IAR project timer3_m23_tpcmp_pwm.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: timer3_m23_tpcmp_pwm.srec
  ILINK.IlinkOutputFile: timer3_m23_tpcmp_pwm.out
  ILINK.IlinkIcfFile: HC32F030.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  group common
    ../../../../mcu/common/: system_hc32f030.c
    ./: startup_hc32f030.s
    ../../../../driver/src/: ddl.c interrupts_hc32f030.c
  group driver
    ../../../../driver/src/: sysctrl.c timer3.c lpm.c gpio.c flash.c adc.c
  group source
    ../source/: main.c
  group README
    ../: readme.txt
