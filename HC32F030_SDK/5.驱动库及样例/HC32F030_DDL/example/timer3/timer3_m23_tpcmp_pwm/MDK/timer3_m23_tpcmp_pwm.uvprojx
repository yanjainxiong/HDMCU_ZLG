# Keil uVision project timer3_m23_tpcmp_pwm.uvprojx, settings and files
target timer3_m23_tpcmp_pwm_Release (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: timer3_m23_tpcmp_pwm
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f030.s
    ../../../../mcu/common/: system_hc32f030.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32f030.c sysctrl.c timer3.c lpm.c gpio.c flash.c adc.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
