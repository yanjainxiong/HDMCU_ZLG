<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timer3_m1_pwc.ewp</path>
  </project>
  <batchBuild/>
</workspace>


