<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\vc_btm0gate_rising_irq.ewp</path>
  </project>
  <batchBuild/>
</workspace>


